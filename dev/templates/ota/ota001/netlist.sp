M1 n1 vinp ntail 0 nch W=2u L=0.18u
M2 n2 vinn ntail 0 nch W=2u L=0.18u
Mtail ntail vbias_n 0 0 nch W=1u L=0.5u
Mp1 vout n2 VDD VDD pch W=4u L=0.18u
Mp2 n1 n1 VDD VDD pch W=4u L=0.18u
VDD VDD 0 1.8
Cload vout 0 1p
