M3 N003 vip N005 0 nch W=2u L=0.18u
M4 N004 vin N005 0 pch W=2u L=0.18u
M2 von vb3 N003 0 nch W=1u L=0.18u
M1 vop vb3 N004 0 nch W=1u L=0.18u
M5 N005 vtail 0 0 nch W=1u L=0.5u
M6 von vb2 N001 VDD pch W=2u L=0.18u
M7 vop vb2 N002 VDD pch W=2u L=0.18u
M8 N001 vb1 VDD VDD pch W=4u L=0.18u
M9 N002 vb1 VDD VDD pch W=4u L=0.18u
C1 vop 0 1p
C2 von 0 1p
VDD VDD 0 1.8
