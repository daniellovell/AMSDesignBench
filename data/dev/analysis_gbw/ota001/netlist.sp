* simple one-stage ota (structural)
M1 vint vinp tail 0 nch W=2u L=0.18u
M2 vint vinn tail 0 nch W=2u L=0.18u
Mtail tail vbias 0 0 nch W=1u L=0.5u
Cload vout 0 1p
* note: no explicit comp cap; CL dominates
