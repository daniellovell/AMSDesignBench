Vin vin 0 AC 1
R1 vin vout 100
L1 vout 0 10m
C1 vout 0 1n
Rload vout 0 1k
