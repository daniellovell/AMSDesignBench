Vin vin 0 AC 1
R1 vin n1 100
L1 n1 vout 10m
C1 vout 0 1n
Rload vout 0 1k
