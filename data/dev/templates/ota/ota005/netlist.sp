M3 N004 vip N006 0 nch W=2u L=0.18u
M4 N005 vin N006 0 nch W=2u L=0.18u
M1 vop vb3 N005 0 nch W=1u L=0.18u
M2 N003 vb3 N004 0 nch W=1u L=0.18u
M5 N006 vtail 0 0 nch W=1u L=0.5u
M6 N003 N003 N001 VDD pch W=2u L=0.18u
M7 vop N003 N002 VDD pch W=2u L=0.18u
M8 N001 N001 VDD VDD pch W=4u L=0.18u
M9 N002 N001 VDD VDD pch W=4u L=0.18u
C1 vop 0 1p
VDD VDD 0 1.8
