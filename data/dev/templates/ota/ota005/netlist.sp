C1 vop 0 1p
M10 N002 N003 vop VDD PMOS l=0.18u w=4u
M6 VDD N001 N002 VDD PMOS l=0.18u w=4u
M7 VDD N001 N001 VDD PMOS l=0.18u w=4u
M8 N001 N003 N003 VDD PMOS l=0.18u w=4u
M9 N003 vb3 N004 0 NMOS l=0.18u w=2u
M1 vop vb3 N005 0 NMOS l=0.18u w=2u
M2 N005 vin N006 0 NMOS l=0.18u w=2u
M3 N004 vip N006 0 NMOS l=0.18u w=2u
M4 N006 vtail 0 0 NMOS l=0.18u w=2u
VDD VDD 0 1.8
