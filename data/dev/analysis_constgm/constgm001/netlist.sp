* constant gm bias hint
Mbias vbias vin 0 0 nch
Rdeg vin 0 1k
Mmir1 iout vbias 0 0 nch
Mmir2 iout vbias 0 0 nch
