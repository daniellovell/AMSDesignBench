Vin vin 0 AC 1
R1 vin vout BLANK
L1 vout 0 BLANK
C1 vout 0 BLANK
Rload vout 0 BLANK
